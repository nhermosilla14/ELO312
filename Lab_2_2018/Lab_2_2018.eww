<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\2.1.1\2.1.1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\2.1.2\2.1.2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\2.1.3\2.1.3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\3.1\3.1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\3.2\3.2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\3.3\3.3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\3.4\3.4.ewp</path>
  </project>
  <batchBuild/>
</workspace>


