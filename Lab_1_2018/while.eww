<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\comparacion.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\proyecto 1 while.ewp</path>
  </project>
  <batchBuild/>
</workspace>


